options:
  parameters:
    author: jboone
    generate_options: qt_gui
    id: nabu_differential_encoder_check
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0, 2, 3, 2, 3]'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Outputs 1 if bit position value is different from last."""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='IQ Delta Encoder',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              # self.example_param = example_param

              self._r = 0b11

          def work(self, input_items, output_items):
              for n, input_item in enumerate(input_items[0]):
                  out = self._r ^ input_item
                  self._r = out
                  output_items[0][n] = out
              return len(output_items[0])
  states: {}
- name: nabu_differential_encoder_0
  id: nabu_differential_encoder
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3.5'
    ymin: '-0.5'
  states: {}

connections:
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_throttle2_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', nabu_differential_encoder_0, '0']
- [blocks_vector_source_x_0_0_0_1, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [nabu_differential_encoder_0, '0', blocks_char_to_float_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
